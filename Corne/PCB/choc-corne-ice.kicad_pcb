# Repository MikeF404/MyKeyboard

File README.md:

# My Keyboards
Files connected with my keyboard - code, stl, and photos
My current main keyboards:
* Corne 
* Dactyl

## Corne
### Details:
* 32 keys + 4 thumb clusters (planning on adding 4 extra))
* Bluetooth, Nice!nano, hotswap
* kinda works with Mac, but the modifiers aren't great to use
* The code is in a different [repo](https://github.com/MikeF404/no-view-corne-config)
* The bottom part has slots for easier grip, battery slot and screw holes

## Dactyl
* focus on cross-platform (Windows + Mac with a KVM switch)
* 70 keys, wired - Teensy 2.0 (Elite-C should work also)
* No PCB - fully hardwired

## KiCad design Corne/PCB/choc-corne-ice.kicad_pcb

Board: 2 copper layers, 275.5 x 105.6 mm, 108 parts (47 on the bottom side), 78 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42: D; D3_SMD_v2
J1, J3: BAT; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
J2, J4: nice!view; PinSocket_1x05_P2.54mm_Vertical
PSW1, PSW2: POWER; switch_SSSS811101
RSW1, RSW2: RST; alps_sksn
Ref**: Val**; M2_HOLE_v2
Ref**#2, Ref**#3, Ref**#4, Ref**#5, Ref**#6, Ref**#7, Ref**#8, Ref**#9, Ref**#10, Ref**#11, Ref**#12, Ref**#13, Ref**#14: Val**; M2_HOLE_v2
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41: SW_PUSH; ChocV1_V2_Hotswap
SW21, SW42: SW_PUSH; ChocV1_V2_Hotswap_1.5u
U1, U2: nice!nano; ProMicro_v3

Connections:
CS: J2.5, U1.1 (TX0/P0.06)
CS_r: J4.5, U2.1 (TX0/P0.06)
GND: J1.2, J2.4, RSW1.2, U1.3 (GND), U1.4 (GND), U1.23 (GND)
GNDA: J3.2, J4.4, RSW2.1, U2.3 (GND), U2.4 (GND), U2.23 (GND)
MOSI: J2.1, U1.5 (P0.17)
MOSI_r: J4.1, U2.5 (P0.17)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: J1.1, PSW1.2 (B)
unnamed: J3.1, PSW2.2 (B)
RAW: PSW1.1 (A), U1.24 (BATIN/P0.04)
RAW_r: PSW2.1 (A), U2.24 (BATIN/P0.04)
SCK: J2.2, U1.6 (P0.20)
SCK_r: J4.2, U2.6 (P0.20)
VCC: J2.3, U1.21 (VCC)
VDD: J4.3, U2.21 (VCC)
col0: SW1.1, SW7.1, SW13.1, U1.20 (AIN7/P0.31)
col0_r: SW22.1, SW28.1, SW34.1, U2.20 (AIN7/P0.31)
col1: SW2.1, SW8.1, SW14.1, U1.19 (AIN5/P0.29)
col1_r: SW23.1, SW29.1, SW35.1, U2.19 (AIN5/P0.29)
col2: SW3.1, SW9.1, SW15.1, U1.18 (AIN0/P0.02)
col2_r: SW24.1, SW30.1, SW36.1, U2.18 (AIN0/P0.02)
col3: SW4.1, SW10.1, SW16.1, SW19.1, U1.17 (P1.15)
col3_r: SW25.1, SW31.1, SW37.1, SW40.1, U2.17 (P1.15)
col4: SW5.1, SW11.1, SW17.1, SW20.1, U1.16 (P1.13)
col4_r: SW26.1, SW32.1, SW38.1, SW41.1, U2.16 (P1.13)
col5: SW6.1, SW12.1, SW18.1, SW21.1, U1.15 (P1.11)
col5_r: SW27.1, SW33.1, SW39.1, SW42.1, U2.15 (P1.11)
reset: RSW1.1, U1.22 (RST)
reset_r: RSW2.2, U2.22 (RST)
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.7 (P0.22)
row0_r: D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), U2.7 (P0.22)
row1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.8 (P0.24)
row1_r: D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), U2.8 (P0.24)
row2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.9 (P1.00)
row2_r: D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), U2.9 (P1.00)
row3: D19.1 (K), D20.1 (K), D21.1 (K), U1.10 (P0.11)
row3_r: D40.1 (K), D41.1 (K), D42.1 (K), U2.10 (P0.11)

## Commit log

2024-06-03 added Dactyl files
2024-06-03 added PCB file
